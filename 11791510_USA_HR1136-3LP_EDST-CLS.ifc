Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-08-25T11:28:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 25 11:28:42 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{C6B5923E-C12D-49A2-BAAE-C2EB588FF321}\ifc * Database version: 5507 * Database creation date: Wed Aug 25 11:28:40 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 25 11:28:41 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 25 11:28:41 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 25113682_USA_11791510_HR1136-3LP_EDST-CLS, 11791510_USA_HR1136-3LP_EDST-CLS:25113682_USA_11791510_HR1136-3LP_EDST-CLS:211690
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_Cast, z_Miele_Connection_Gas, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - Reference: 25113682_USA_11791510_HR1136-3LP_EDST-CLS
